# Keil uVision project Ble_Mesh_Kp.uvprojx, settings and files
target Ble_Mesh_Kp (6230000::V6.23::ARMCLANG)
  device: STM32WB5MMGHx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.2.0.1
  cpu: IRAM(0x20000008-0x2002FC07) IROM(0x08000000-0x807FBFF) IRAM2(0x20030000-0x200323FF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Ble_Mesh_Kp +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STM32WBXX_NUCLEO,USE_HAL_DRIVER,STM32WB5Mxx,ENABLE_USART
  c include: ../Core/Inc;../Drivers/STM32WBxx_HAL_Driver/Inc;../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../Drivers/CMSIS/Include;../STM32_WPAN/App;../Middlewares/ST/STM32_WPAN/ble/mesh/Inc;../Middlewares/ST/STM32_WPAN/ble/mesh/MeshModel/Inc;../Utilities/lpm/tiny_lpm;../Middlewares/ST/STM32_WPAN;../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../Middlewares/ST/STM32_WPAN/utilities;../Middlewares/ST/STM32_WPAN/ble/core;../Middlewares/ST/STM32_WPAN/ble/core/auto;../Middlewares/ST/STM32_WPAN/ble/core/template;../Middlewares/ST/STM32_WPAN/ble/svc/Inc;../Middlewares/ST/STM32_WPAN/ble/svc/Src;../Utilities/sequencer;../Middlewares/ST/STM32_WPAN/ble;../Middlewares/ST/lib_nfc7/Common/inc/;../Middlewares/ST/lib_nfc7/lib_NDEF/Core/inc/;../NFC7/Target/;../Drivers/BSP/NFC07A1/;../Drivers/BSP/Components/st25dvxxkc/;../Drivers/BSP/P-NUCLEO-WB55.Nucleo/
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000008 size 0x2fc00
  memory RVCT10: RAM 0x20030000 size 0x2400
  scatter file: stm32wb5mxx_flash_cm4_ota.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
--keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
  group Application/MDK-ARM
    ./: startup_stm32wb5mxx_cm4.s
  group Application/User/Core
    ../Core/Src/: ctor10-w_data.c nfc_eeprom_mngt.c flash_driver.c stm32wbxx_nucleo_bus.c main.c app_entry.c app_debug.c hw_timerserver.c stm32_lpm_if.c stm32wbxx_it.c stm32wbxx_hal_msp.c hw_uart.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_crc.c stm32wbxx_hal_crc_ex.c stm32wbxx_hal_rcc.c stm32wbxx_ll_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: bas_app.c dis_app.c app_ble.c p2p_server_app.c appli_mesh.c appli_nvm.c appli_vendor.c models_if.c pal_nvm.c appli_generic.c appli_light.c appli_light_lc.c appli_sensor.c appli_generic_client.c appli_light_client.c appli_sensors_client.c appli_config.c appli_config_client.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Middlewares/STM32_WPAN
    ../Middlewares/ST/STM32_WPAN/ble/svc/Src/: bas.c dis.c p2p_stm.c svc_ctl.c mesh.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: tl_mbox.c hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../Middlewares/ST/STM32_WPAN/ble/mesh/Src/: mesh_cfg.c
    ../Middlewares/ST/STM32_WPAN/ble/mesh/MeshModel/Src/: common.c generic.c light.c light_lc.c sensors.c time_scene.c vendor.c generic_client.c light_client.c sensors_client.c config_client.c
  group Utilities
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../Utilities/sequencer/: stm32_seq.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/st25dvxxkc/: st25dvxxkc.c st25dvxxkc_reg.c
  group Drivers/BSP/NFC07A1
    ../Drivers/BSP/NFC07A1/: nfc07a1.c nfc07a1_nfctag.c
  group Middlewares/lib_nfc7/Wireless/lib_nfc7/Core
    ../Middlewares/ST/lib_nfc7/lib_NDEF/Core/src/: lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Bluetooth.c lib_NDEF_config.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_Handover.c lib_NDEF_MyApp.c lib_NDEF_SMS.c lib_NDEF_Text.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_NDEF_Wifi.c lib_wrapper.c tagtype3_wrapper.c tagtype4_wrapper.c tagtype5_wrapper.c
  group Drivers/BSP/STM32WBxx_Nucleo
    ../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Middlewares/ST/STM32_WPAN/ble/mesh/Library
    ../Middlewares/ST/STM32_WPAN/ble/mesh/Library/: libBle_Mesh_CM4_Keil.lib
software components: CMSIS:CORE 5.6.0
